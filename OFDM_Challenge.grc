options:
  parameters:
    author: Sam
    generate_options: qt_gui
    id: default
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: Signal_Center_Freq
  id: variable_qtgui_range
  parameters:
    start: '-600e6'
    step: 100e3
    stop: 600e6
    value: 300e6
  states: {}
- name: band_pass_high_cutoff
  id: variable_qtgui_range
  parameters:
    start: '1'
    step: '1'
    stop: 10e6
    value: 5e6
  states: {state: disabled}
- name: band_pass_low_cutoff
  id: variable_qtgui_range
  parameters:
    start: '1'
    step: '1'
    stop: 10e6
    value: 2e6
  states: {state: disabled}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: transition_width
  id: variable_qtgui_range
  parameters:
    start: '1'
    step: '1'
    stop: '1000'
    value: '400'
  states: {state: disabled}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: '0'
    type: float
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: Signal_Center_Freq
    offset: '0'
    phase: '0'
    samp_rate: 20e6
    type: complex
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: band_pass_high_cutoff
    low_cutoff_freq: band_pass_low_cutoff
    samp_rate: 20e6
    type: fir_filter_ccc
    width: transition_width
    win: window.WIN_HAMMING
  states: {state: bypassed}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: 10e3
    type: complex
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: C:\Users\Sam\Desktop\GNU Radio Projects\GMR-DSP-OFDM\OFDM_IQ_SIM_256Char.wav
    repeat: 'False'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: 20e6
    ctrlpanel: 'True'
    fc: 300e6
    fftsize: '1024'
    label1: Raw
    label2: Multiplied
    nconnections: '2'
    type: complex
  states: {}

connections:
- [analog_const_source_x_0, '0', blocks_float_to_complex_0, '1']
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '1']
- [band_pass_filter_0, '0', blocks_throttle2_0, '0']
- [blocks_float_to_complex_0, '0', blocks_multiply_xx_0, '0']
- [blocks_float_to_complex_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_multiply_xx_0, '0', band_pass_filter_0, '0']
- [blocks_throttle2_0, '0', qtgui_freq_sink_x_0, '1']
- [blocks_wavfile_source_0, '0', blocks_float_to_complex_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
