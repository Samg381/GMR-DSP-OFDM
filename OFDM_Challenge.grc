options:
  parameters:
    author: Sam
    generate_options: qt_gui
    id: default
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: Signal_Center_Freq
  id: variable_qtgui_range
  parameters:
    start: '-3e6'
    step: 100e3
    stop: 3e6
    value: '-3e6'
  states: {}
- name: band_pass_high_cutoff
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: 100e6
    value: 50e4
  states: {}
- name: band_pass_low_cutoff
  id: variable_qtgui_range
  parameters:
    start: '-100e6'
    step: '1'
    stop: '0'
    value: '-5e4'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: '0'
    type: float
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: Signal_Center_Freq
    offset: '0'
    phase: '0'
    samp_rate: 20e6
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: 10e6
    type: complex
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: C:\Users\Sam\Desktop\GNU Radio Projects\GMR-DSP-OFDM\OFDM_IQ_SIM_256Char.wav
    repeat: 'True'
  states: {}
- name: high_pass_filter_0
  id: high_pass_filter
  parameters:
    cutoff_freq: 400e6
    decim: '1'
    gain: '1'
    samp_rate: 800e6
    type: fir_filter_ccf
    width: '12'
    win: window.WIN_HAMMING
  states: {state: disabled}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: 20e6
    ctrlpanel: 'True'
    fc: '0'
    fftsize: '1024'
    label1: Raw Signal
    label2: Multiplied
    nconnections: '2'
    type: complex
  states: {}

connections:
- [analog_const_source_x_0, '0', blocks_float_to_complex_0, '1']
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '1']
- [blocks_float_to_complex_0, '0', blocks_multiply_xx_0, '0']
- [blocks_float_to_complex_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_multiply_xx_0, '0', blocks_throttle2_0, '0']
- [blocks_throttle2_0, '0', qtgui_freq_sink_x_0, '1']
- [blocks_wavfile_source_0, '0', blocks_float_to_complex_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
